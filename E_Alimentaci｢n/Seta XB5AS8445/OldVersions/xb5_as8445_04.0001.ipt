# Autodesk Inventor part: xb5_as8445_04
Saved by Autodesk Inventor 2015 (Build 190159000, 159)
## iProperties
Created: 2018-04
Part Number: xb5_as8445_04
Checked By: TraceParts S.A.
Material: Generic
Catalog Web Link: www.traceparts.com
Document SubType Name: Modeling
Designer: TraceParts
Density: 1 g/cm^3
Appearance: Default
Company: TraceParts S.A.
Author: TraceParts
## Design history (mm, degrees)
feature "xb5_as8445_04.ipt"
body "Solid1"
