# Autodesk Inventor part: xb5_ad33_03
Saved by Autodesk Inventor 2015 (Build 190159000, 159)
## iProperties
Created: 2018-05
Part Number: xb5_ad33_03
Checked By: TraceParts S.A.
Material: Generic
Catalog Web Link: www.traceparts.com
Document SubType Name: Modeling
Designer: TraceParts
Density: 1 g/cm^3
Appearance: Default
Company: TraceParts S.A.
Author: TraceParts
## Design history (mm, degrees)
feature "xb5_ad33_03.ipt"
body "Solid1"
